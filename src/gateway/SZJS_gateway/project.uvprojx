# Keil uVision project project.uvprojx, settings and files
target RT-Thread STM32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207VG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-stm32 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: applications;.;config;.;drivers;Libraries\STM32F2xx_StdPeriph_Driver\inc;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;misc;.;services;.;..\..\RTT_2_1_0\include;..\..\RTT_2_1_0\libcpu\arm\cortex-m3;..\..\RTT_2_1_0\libcpu\arm\common;..\..\RTT_2_1_0\components\dfs\include;..\..\RTT_2_1_0\components\dfs\filesystems\elmfat;..\..\RTT_2_1_0\components\dfs\filesystems\romfs;..\..\RTT_2_1_0\components\drivers\include;..\..\RTT_2_1_0\components\drivers\include;..\..\RTT_2_1_0\components\drivers\include;..\..\RTT_2_1_0\components\drivers\spi;..\..\RTT_2_1_0\components\drivers\i2c;..\..\RTT_2_1_0\components\drivers\include;..\..\RTT_2_1_0\components\drivers\include;..\..\RTT_2_1_0\components\finsh;..\..\RTT_2_1_0\components\libdl;..\..\RTT_2_1_0\components\net\lwip-1.4.1\src;..\..\RTT_2_1_0\components\net\lwip-1.4.1\src\include;..\..\RTT_2_1_0\components\net\lwip-1.4.1\src\include\ipv4;..\..\RTT_2_1_0\components\net\lwip-1.4.1\src\arch\include;..\..\RTT_2_1_0\components\net\lwip-1.4.1\src\include\netif;..\..\RTT_2_1_0\components\utilities\logtrace;..\..\RTT_2_1_0\components\utilities\ymodem
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep *.o(RTMSymTab)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c selftest.c UITD_main.c UITD_eth.c startup.c sys_misc.c UITD.c sys_status.c sensor_sample.c fire_alarm.c controller.c sntp.c UITD_BLE.c UITD_WIFI.c transparent.c
    ./applications/: pro_ctrl.c pro_UITD.c
  group Drivers
    drivers/: board.c stm32f2xx_it.c usart.c rtc.c platform.c GSM_MG301.c WIFI_ESP_07.c spi_flash_w25qxx.c timer.c ADC.c msd.c VK3266.c MCP23X17.c stm32f2xx_eth_LAN8720A.c gpio.c stm32f20x_40x_spi.c stm32_i2c.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
    Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group misc
    misc/: memlog.c cpuusage.c CRC16.c tofile.c init_rc.c
  group services
    services/: cJSON.c JSON_config.c COM_if.c GPRS_server.c sw_crc.c
    ./services/: IOT_digit_in.c IOT_analog_in.c IOT_digit_out.c
  group Kernel
    ../../RTT_2_1_0/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../RTT_2_1_0/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../RTT_2_1_0/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../RTT_2_1_0/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../RTT_2_1_0/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../RTT_2_1_0/components/dfs/filesystems/elmfat/option/: ccsbcs.c
    ../../RTT_2_1_0/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group DeviceDrivers
    ../../RTT_2_1_0/components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../RTT_2_1_0/components/drivers/misc/: pin.c
    ../../RTT_2_1_0/components/drivers/serial/: serial.c
    ../../RTT_2_1_0/components/drivers/spi/: spi_core.c spi_dev.c
    ../../RTT_2_1_0/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../RTT_2_1_0/components/drivers/i2c/: i2c-bit-ops.c
  group finsh
    ../../RTT_2_1_0/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libdl
    ../../RTT_2_1_0/components/libdl/: dlclose.c dlerror.c dlopen.c dlsym.c
  group LwIP
    ../../RTT_2_1_0/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../RTT_2_1_0/components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../../RTT_2_1_0/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../RTT_2_1_0/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../RTT_2_1_0/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group Utilities
    ../../RTT_2_1_0/components/utilities/logtrace/: log_file.c log_trace.c
    ../../RTT_2_1_0/components/utilities/ymodem/: ymodem.c
software components: CMSIS:CORE 4.3.0
