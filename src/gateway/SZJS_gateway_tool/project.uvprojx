# Keil uVision project project.uvprojx, settings and files
target RT-Thread STM32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F205RETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SZJS_gateway +hex
  BeforeMake: build_before.bat
  AfterMake: fromelf --bin !L --output rtthread.bin
  AfterMake: BIN_encode -e rtthread.bin firmware.bin 87181
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: applications;.;config;.;drivers;Libraries\STM32F2xx_StdPeriph_Driver\inc;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;misc;.;services;.;stm32flash;..\..\RTT_2_1_0\include;..\..\RTT_2_1_0\libcpu\arm\cortex-m4;..\..\RTT_2_1_0\libcpu\arm\common;..\..\RTT_2_1_0\components\dfs\include;..\..\RTT_2_1_0\components\dfs\filesystems\elmfat;..\..\RTT_2_1_0\components\drivers\include;..\..\RTT_2_1_0\components\drivers\include;..\..\RTT_2_1_0\components\drivers\spi;..\..\RTT_2_1_0\components\drivers\include;..\..\RTT_2_1_0\components\drivers\include;..\..\RTT_2_1_0\components\finsh;..\..\RTT_2_1_0\components\libdl;..\..\RTT_2_1_0\components\utilities\logtrace;..\..\RTT_2_1_0\components\utilities\ymodem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep *.o(RTMSymTab)  --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c startup.c sys_misc.c sys_status.c
  group Drivers
    drivers/: board.c stm32f2xx_it.c usart.c rtc.c platform.c spi_flash_w25qxx.c flash_if.c en_de_code.c msd.c gpio.c stm32f20x_40x_spi.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
    Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group misc
    misc/: memlog.c tofile.c init_rc.c
  group services
    services/: cJSON.c JSON_config.c
  group stm32flash
    stm32flash/: ISP_main.c dev_table.c init.c port.c serial_common.c serial_platform.c stm32.c utils.c
    stm32flash/parsers/: binary.c hex.c
  group Kernel
    ../../RTT_2_1_0/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../RTT_2_1_0/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../RTT_2_1_0/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../RTT_2_1_0/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../RTT_2_1_0/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../RTT_2_1_0/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../RTT_2_1_0/components/drivers/misc/: pin.c
    ../../RTT_2_1_0/components/drivers/serial/: serial.c
    ../../RTT_2_1_0/components/drivers/spi/: spi_core.c spi_dev.c
    ../../RTT_2_1_0/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../RTT_2_1_0/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libdl
    ../../RTT_2_1_0/components/libdl/: dlclose.c dlerror.c dlopen.c dlsym.c
  group Utilities
    ../../RTT_2_1_0/components/utilities/logtrace/: log_file.c log_trace.c
    ../../RTT_2_1_0/components/utilities/ymodem/: ymodem.c
