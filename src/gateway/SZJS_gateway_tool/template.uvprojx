# Keil uVision project template.uvprojx, settings and files
target RT-Thread STM32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F205RETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SZJS_gateway +hex
  BeforeMake: build_before.bat
  AfterMake: fromelf --bin !L --output rtthread.bin
  AfterMake: BIN_encode -e rtthread.bin firmware.bin 87181
  c flags: Optim=1 uC99=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
